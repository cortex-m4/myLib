# Keil uVision project OLED_Demo.uvprojx, settings and files
target OLED_Demo (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: OLED_Demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G070xx,USE_U8G2
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;..\myLib\i2c;..\myLib\oled;..\otherLib\u8g2\csrc;..\otherLib\simpleGUI\DemoProc\inc;..\otherLib\simpleGUI\GUI\inc;..\otherLib\simpleGUI\HMI\inc;..\otherLib\simpleGUI\BSP\inc;..\myLib\key
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/MDK-ARM
    ./: startup_stm32g070xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group myLib
    ../myLib/i2c/: software_i2c.c
    ../myLib/oled/: OLED.c
    ../myLib/key/: lib_key.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group otherLib/u8g2
    ../otherLib/u8g2/csrc/: u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_a2printer.c u8x8_d_ssd1306_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group otherLib/SimpleGUI/GUI
    ../otherLib/simpleGUI/GUI/src/: SGUI_Basic.c SGUI_Common.c SGUI_Curve.c SGUI_FontResource.c SGUI_IconResource.c SGUI_Interface.c SGUI_ItemsBase.c SGUI_List.c SGUI_Menu.c SGUI_Notice.c SGUI_ProcessBar.c SGUI_RealtimeGraph.c SGUI_ScrollBar.c SGUI_Text.c SGUI_VariableBox.c
  group otherLib/SimpleGUI/HMI
    ../otherLib/simpleGUI/HMI/src/: HMI_Engine.c
  group otherLib/SimpleGUI/Demo
    ../otherLib/simpleGUI/DemoProc/src/: Basic.c Curve.c List.c Menu.c Notice.c RealtimeGraph.c Resource.c Text.c VariableBox.c DemoProc.c
  group otherLib/SimpleGUI/Bsp
    ../otherLib/simpleGUI/BSP/src/: screen.c trigger_flags.c
software components: CMSIS:CORE 4.3.0
